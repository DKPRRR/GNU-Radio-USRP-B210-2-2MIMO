options:
  parameters:
    generate_options: qt_gui
    id: mimo22
    output_language: python
    title: mimo22
  states: {}

blocks:
- name: button_msg
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: '"调试/发送文件"'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: data_len
  id: variable
  parameters:
    comment: 单位：Byte
    value: '496'
  states: {}
- name: data_len_len
  id: variable
  parameters:
    comment: 单位：Byte
    value: '2'
  states: {state: disabled}
- name: data_modulator
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"/home/adminx/mytest2/a.jpg"'
  states: {}
- name: frame_len
  id: variable
  parameters:
    comment: 单位：Byte
    value: frame_number_len+data_len_len+data_len
  states: {state: disabled}
- name: frame_number_len
  id: variable
  parameters:
    comment: 单位：Byte
    value: '2'
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '35'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: lms
  id: variable_adaptive_algorithm
  parameters:
    cons: data_modulator
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfilts
    ntaps: 11*sample_rate*nfilts
    samp_rate: nfilts*sample_rate
    sym_rate: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: threshold
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx1_preamble
  id: variable
  parameters:
    value: '[0]*32 + zc1 + [0]*32 + [0]*61 + [0]*32'
  states: {}
- name: tx2_preamble
  id: variable
  parameters:
    value: '[0]*32 + [0]*61 +[0]*32 + zc2 + [0]*32'
  states: {}
- name: zc1
  id: variable
  parameters:
    value: '[complex(np.exp(-1j * np.pi * 25 * n * (n + 1) / 61)) for n in range(61)]'
  states: {}
- name: zc1_rrced
  id: variable
  parameters:
    value: vr.rrc_interpolation_filter(zc1, 4, 1, 0.35, 11*sample_rate)
  states: {}
- name: zc2
  id: variable
  parameters:
    value: '[complex(np.exp(-1j * np.pi * 34 * n * (n + 1) / 61)) for n in range(61)]'
  states: {}
- name: zc2_rrced
  id: variable
  parameters:
    value: vr.rrc_interpolation_filter(zc2, 4, 1, 0.35, 11*sample_rate)
  states: {}
- name: zc_modulator
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '218'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '218'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_1_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: tx1_preamble
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: tx2_preamble
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: data_modulator
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: data_modulator
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: '0'
    alg: lms
    num_taps: '15'
    sps: '1'
  states: {state: disabled}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: '0'
    alg: lms
    num_taps: '15'
    sps: '1'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: '0.02'
    max_dev: '0.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: '0.02'
    max_dev: '0.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      GNU Radio 2x2 MIMO 信道模拟 Block
      模拟功能: r = H*s + N (信道变换 + 噪声)
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """2x2 MIMO 信道模拟器"""

          def __init__(self, noise_pow=0.1, seed=42):
              """
              初始化参数:
              - noise_pow: 噪声功率 (线性标度)
              - seed: 随机种子 (固定种子保证可重复性)
              """
              gr.sync_block.__init__(
                  self,
                  name='2x2 MIMO Channel',
                  in_sig=[np.complex64, np.complex64],      # TX1, TX2 输入
                  out_sig=[np.complex64, np.complex64]      # RX1, RX2 输出
              )
              
              self.noise_pow = noise_pow
              
              # 初始化信道矩阵 H (使用固定种子保证可重复)
              np.random.seed(seed)
              self.H = (np.random.randn(2, 2) + 1j * np.random.randn(2, 2)) / np.sqrt(2)

          def _add_awgn(self, signal, noise_pow):
              """添加加性高斯白噪声"""
              if noise_pow <= 0:
                  return signal
              
              sigma = np.sqrt(noise_pow / 2)  # 实部和虚部各占一半功率
              noise = (np.random.normal(0, sigma, len(signal)) + 
                      1j * np.random.normal(0, sigma, len(signal)))
              return signal + noise

          def work(self, input_items, output_items):
              """主处理函数: r = H*s + N"""
              in_tx1 = input_items[0].astype(np.complex128)  # TX1 信号
              in_tx2 = input_items[1].astype(np.complex128)  # TX2 信号
              n_samples = len(in_tx1)
              
              # 输出缓冲
              out_rx1 = output_items[0]
              out_rx2 = output_items[1]
              
              # 信道变换: r = H*s
              # RX1 = h11*TX1 + h12*TX2
              # RX2 = h21*TX1 + h22*TX2
              rx1 = self.H[0, 0] * in_tx1 + self.H[0, 1] * in_tx2
              rx2 = self.H[1, 0] * in_tx1 + self.H[1, 1] * in_tx2
              
              # 添加噪声 N
              rx1 = self._add_awgn(rx1, self.noise_pow)
              rx2 = self._add_awgn(rx2, self.noise_pow)
              
              # 输出
              out_rx1[:] = rx1.astype(np.complex64)
              out_rx2[:] = rx2.astype(np.complex64)
              
              return n_samples
    noise_pow: '0.1'
    seed: '44'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Correlation Estimator - 使用归一化互相关检测导频序列并标记起始位置

          参数:
              symbols: 导频序列（复数列表）
              sps: 每符号采样数
              threshold: 归一化相关阈值 (0~1)
              tag_name: 检测到导频时输出的 tag 名称
          """

          def __init__(self, symbols=[], sps=1, threshold=0.7, tag_name="corr_start"):
              gr.sync_block.__init__(
                  self,
                  name='Correlation Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sps = int(sps)
              self.threshold = float(threshold)
              self.tag_name = str(tag_name)

              # 生成参考序列（支持升采样）
              symbols_arr = np.array(symbols, dtype=np.complex64)
              if self.sps > 1:
                  self.ref = np.repeat(symbols_arr, self.sps)
              else:
                  self.ref = symbols_arr.copy()

              self.ref_len = len(self.ref)
              if self.ref_len == 0:
                  self.ref = np.array([1 + 0j], dtype=np.complex64)
                  self.ref_len = 1

              self.ref_conj = np.conj(self.ref)  # 用于直接点积计算
              self.ref_energy = float(np.sum(np.abs(self.ref) ** 2))

              # 设置 history 以支持缓冲区边界处的相关计算
              self.set_history(self.ref_len)

              # 最小检测间距 (防止同一导频序列产生多次检测)
              self.last_tag_abs = -(self.ref_len * 10)

          def set_threshold(self, threshold):
              """运行时更新阈值"""
              self.threshold = float(threshold)

          def work(self, input_items, output_items):
              inp = input_items[0]  # 长度 = nout + ref_len - 1 (包含 history)
              out = output_items[0]
              nout = len(out)

              # 直通数据（跳过 history 部分）
              out[:] = inp[self.ref_len - 1: self.ref_len - 1 + nout]

              if nout == 0:
                  return nout

              nread = self.nitems_read(0)
              total_inp = nout + self.ref_len - 1

              # np.correlate(x, h, 'valid')[i] = sum_k x[i+k] * conj(h[k])
              # numpy 会自动对第二个参数取共轭，所以传入 self.ref 而非 self.ref_conj
              corr_abs = np.abs(np.correlate(inp[:total_inp], self.ref, mode='valid'))

              # ========== 滑窗能量归一化 ==========
              inp_sq = np.abs(inp[:total_inp]).astype(np.float64) ** 2
              cumsum = np.cumsum(inp_sq)

              win_energy = np.empty(nout, dtype=np.float64)
              win_energy[0] = cumsum[self.ref_len - 1]
              if nout > 1:
                  win_energy[1:] = (cumsum[self.ref_len: self.ref_len + nout - 1]
                                    - cumsum[: nout - 1])

              # 归一化: rho = |corr| / sqrt(E_window * E_ref)
              denom = np.sqrt(np.maximum(win_energy * self.ref_energy, 1e-30))
              norm_corr = corr_abs[:nout] / denom

              # ========== 峰值检测 ==========
              above_mask = norm_corr > self.threshold
              if not np.any(above_mask):
                  return nout

              above_indices = np.where(above_mask)[0]

              # 将连续超阈值区域分组，在每组中找峰值
              breaks = np.where(np.diff(above_indices) > 1)[0] + 1
              groups = np.split(above_indices, breaks)

              min_distance = self.ref_len

              for group in groups:
                  if len(group) == 0:
                      continue

                  # 在组内找最大归一化相关值的位置
                  peak_idx = group[np.argmax(norm_corr[group])]

                  # 只处理能映射到有效输出位置的峰值
                  # correlation at index i => ZC starts at inp[i]
                  # inp[i] 的绝对位置 = nread - (ref_len - 1) + i
                  # 要使 tag 落在当前输出范围内: i >= ref_len - 1
                  if peak_idx < self.ref_len - 1:
                      continue

                  # ZC 序列开始的绝对流位置
                  zc_start_abs = nread + (peak_idx - (self.ref_len - 1))

                  # 距上次检测的去重检查
                  if zc_start_abs - self.last_tag_abs < min_distance:
                      continue

                  # 添加 tag 标记导频起始位置
                  self.add_item_tag(
                      0,
                      zc_start_abs,
                      pmt.intern(self.tag_name),
                      pmt.from_double(float(norm_corr[peak_idx]))
                  )
                  self.last_tag_abs = zc_start_abs

              return nout
    sps: '1'
    symbols: zc1_rrced
    tag_name: '"h11_corr_start"'
    threshold: threshold
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Correlation Estimator - 使用归一化互相关检测导频序列并标记起始位置

          参数:
              symbols: 导频序列（复数列表）
              sps: 每符号采样数
              threshold: 归一化相关阈值 (0~1)
              tag_name: 检测到导频时输出的 tag 名称
          """

          def __init__(self, symbols=[], sps=1, threshold=0.7, tag_name="corr_start"):
              gr.sync_block.__init__(
                  self,
                  name='Correlation Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sps = int(sps)
              self.threshold = float(threshold)
              self.tag_name = str(tag_name)

              # 生成参考序列（支持升采样）
              symbols_arr = np.array(symbols, dtype=np.complex64)
              if self.sps > 1:
                  self.ref = np.repeat(symbols_arr, self.sps)
              else:
                  self.ref = symbols_arr.copy()

              self.ref_len = len(self.ref)
              if self.ref_len == 0:
                  self.ref = np.array([1 + 0j], dtype=np.complex64)
                  self.ref_len = 1

              self.ref_conj = np.conj(self.ref)  # 用于直接点积计算
              self.ref_energy = float(np.sum(np.abs(self.ref) ** 2))

              # 设置 history 以支持缓冲区边界处的相关计算
              self.set_history(self.ref_len)

              # 最小检测间距 (防止同一导频序列产生多次检测)
              self.last_tag_abs = -(self.ref_len * 10)

          def set_threshold(self, threshold):
              """运行时更新阈值"""
              self.threshold = float(threshold)

          def work(self, input_items, output_items):
              inp = input_items[0]  # 长度 = nout + ref_len - 1 (包含 history)
              out = output_items[0]
              nout = len(out)

              # 直通数据（跳过 history 部分）
              out[:] = inp[self.ref_len - 1: self.ref_len - 1 + nout]

              if nout == 0:
                  return nout

              nread = self.nitems_read(0)
              total_inp = nout + self.ref_len - 1

              # np.correlate(x, h, 'valid')[i] = sum_k x[i+k] * conj(h[k])
              # numpy 会自动对第二个参数取共轭，所以传入 self.ref 而非 self.ref_conj
              corr_abs = np.abs(np.correlate(inp[:total_inp], self.ref, mode='valid'))

              # ========== 滑窗能量归一化 ==========
              inp_sq = np.abs(inp[:total_inp]).astype(np.float64) ** 2
              cumsum = np.cumsum(inp_sq)

              win_energy = np.empty(nout, dtype=np.float64)
              win_energy[0] = cumsum[self.ref_len - 1]
              if nout > 1:
                  win_energy[1:] = (cumsum[self.ref_len: self.ref_len + nout - 1]
                                    - cumsum[: nout - 1])

              # 归一化: rho = |corr| / sqrt(E_window * E_ref)
              denom = np.sqrt(np.maximum(win_energy * self.ref_energy, 1e-30))
              norm_corr = corr_abs[:nout] / denom

              # ========== 峰值检测 ==========
              above_mask = norm_corr > self.threshold
              if not np.any(above_mask):
                  return nout

              above_indices = np.where(above_mask)[0]

              # 将连续超阈值区域分组，在每组中找峰值
              breaks = np.where(np.diff(above_indices) > 1)[0] + 1
              groups = np.split(above_indices, breaks)

              min_distance = self.ref_len

              for group in groups:
                  if len(group) == 0:
                      continue

                  # 在组内找最大归一化相关值的位置
                  peak_idx = group[np.argmax(norm_corr[group])]

                  # 只处理能映射到有效输出位置的峰值
                  # correlation at index i => ZC starts at inp[i]
                  # inp[i] 的绝对位置 = nread - (ref_len - 1) + i
                  # 要使 tag 落在当前输出范围内: i >= ref_len - 1
                  if peak_idx < self.ref_len - 1:
                      continue

                  # ZC 序列开始的绝对流位置
                  zc_start_abs = nread + (peak_idx - (self.ref_len - 1))

                  # 距上次检测的去重检查
                  if zc_start_abs - self.last_tag_abs < min_distance:
                      continue

                  # 添加 tag 标记导频起始位置
                  self.add_item_tag(
                      0,
                      zc_start_abs,
                      pmt.intern(self.tag_name),
                      pmt.from_double(float(norm_corr[peak_idx]))
                  )
                  self.last_tag_abs = zc_start_abs

              return nout
    sps: '1'
    symbols: zc2_rrced
    tag_name: '"h21_corr_start"'
    threshold: threshold
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Correlation Estimator - 使用归一化互相关检测导频序列并标记起始位置

          参数:
              symbols: 导频序列（复数列表）
              sps: 每符号采样数
              threshold: 归一化相关阈值 (0~1)
              tag_name: 检测到导频时输出的 tag 名称
          """

          def __init__(self, symbols=[], sps=1, threshold=0.7, tag_name="corr_start"):
              gr.sync_block.__init__(
                  self,
                  name='Correlation Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sps = int(sps)
              self.threshold = float(threshold)
              self.tag_name = str(tag_name)

              # 生成参考序列（支持升采样）
              symbols_arr = np.array(symbols, dtype=np.complex64)
              if self.sps > 1:
                  self.ref = np.repeat(symbols_arr, self.sps)
              else:
                  self.ref = symbols_arr.copy()

              self.ref_len = len(self.ref)
              if self.ref_len == 0:
                  self.ref = np.array([1 + 0j], dtype=np.complex64)
                  self.ref_len = 1

              self.ref_conj = np.conj(self.ref)  # 用于直接点积计算
              self.ref_energy = float(np.sum(np.abs(self.ref) ** 2))

              # 设置 history 以支持缓冲区边界处的相关计算
              self.set_history(self.ref_len)

              # 最小检测间距 (防止同一导频序列产生多次检测)
              self.last_tag_abs = -(self.ref_len * 10)

          def set_threshold(self, threshold):
              """运行时更新阈值"""
              self.threshold = float(threshold)

          def work(self, input_items, output_items):
              inp = input_items[0]  # 长度 = nout + ref_len - 1 (包含 history)
              out = output_items[0]
              nout = len(out)

              # 直通数据（跳过 history 部分）
              out[:] = inp[self.ref_len - 1: self.ref_len - 1 + nout]

              if nout == 0:
                  return nout

              nread = self.nitems_read(0)
              total_inp = nout + self.ref_len - 1

              # np.correlate(x, h, 'valid')[i] = sum_k x[i+k] * conj(h[k])
              # numpy 会自动对第二个参数取共轭，所以传入 self.ref 而非 self.ref_conj
              corr_abs = np.abs(np.correlate(inp[:total_inp], self.ref, mode='valid'))

              # ========== 滑窗能量归一化 ==========
              inp_sq = np.abs(inp[:total_inp]).astype(np.float64) ** 2
              cumsum = np.cumsum(inp_sq)

              win_energy = np.empty(nout, dtype=np.float64)
              win_energy[0] = cumsum[self.ref_len - 1]
              if nout > 1:
                  win_energy[1:] = (cumsum[self.ref_len: self.ref_len + nout - 1]
                                    - cumsum[: nout - 1])

              # 归一化: rho = |corr| / sqrt(E_window * E_ref)
              denom = np.sqrt(np.maximum(win_energy * self.ref_energy, 1e-30))
              norm_corr = corr_abs[:nout] / denom

              # ========== 峰值检测 ==========
              above_mask = norm_corr > self.threshold
              if not np.any(above_mask):
                  return nout

              above_indices = np.where(above_mask)[0]

              # 将连续超阈值区域分组，在每组中找峰值
              breaks = np.where(np.diff(above_indices) > 1)[0] + 1
              groups = np.split(above_indices, breaks)

              min_distance = self.ref_len

              for group in groups:
                  if len(group) == 0:
                      continue

                  # 在组内找最大归一化相关值的位置
                  peak_idx = group[np.argmax(norm_corr[group])]

                  # 只处理能映射到有效输出位置的峰值
                  # correlation at index i => ZC starts at inp[i]
                  # inp[i] 的绝对位置 = nread - (ref_len - 1) + i
                  # 要使 tag 落在当前输出范围内: i >= ref_len - 1
                  if peak_idx < self.ref_len - 1:
                      continue

                  # ZC 序列开始的绝对流位置
                  zc_start_abs = nread + (peak_idx - (self.ref_len - 1))

                  # 距上次检测的去重检查
                  if zc_start_abs - self.last_tag_abs < min_distance:
                      continue

                  # 添加 tag 标记导频起始位置
                  self.add_item_tag(
                      0,
                      zc_start_abs,
                      pmt.intern(self.tag_name),
                      pmt.from_double(float(norm_corr[peak_idx]))
                  )
                  self.last_tag_abs = zc_start_abs

              return nout
    sps: '1'
    symbols: zc2_rrced
    tag_name: '"h22_corr_start"'
    threshold: threshold
  states: {}
- name: epy_block_1_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Correlation Estimator - 使用归一化互相关检测导频序列并标记起始位置

          参数:
              symbols: 导频序列（复数列表）
              sps: 每符号采样数
              threshold: 归一化相关阈值 (0~1)
              tag_name: 检测到导频时输出的 tag 名称
          """

          def __init__(self, symbols=[], sps=1, threshold=0.7, tag_name="corr_start"):
              gr.sync_block.__init__(
                  self,
                  name='Correlation Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sps = int(sps)
              self.threshold = float(threshold)
              self.tag_name = str(tag_name)

              # 生成参考序列（支持升采样）
              symbols_arr = np.array(symbols, dtype=np.complex64)
              if self.sps > 1:
                  self.ref = np.repeat(symbols_arr, self.sps)
              else:
                  self.ref = symbols_arr.copy()

              self.ref_len = len(self.ref)
              if self.ref_len == 0:
                  self.ref = np.array([1 + 0j], dtype=np.complex64)
                  self.ref_len = 1

              self.ref_conj = np.conj(self.ref)  # 用于直接点积计算
              self.ref_energy = float(np.sum(np.abs(self.ref) ** 2))

              # 设置 history 以支持缓冲区边界处的相关计算
              self.set_history(self.ref_len)

              # 最小检测间距 (防止同一导频序列产生多次检测)
              self.last_tag_abs = -(self.ref_len * 10)

          def set_threshold(self, threshold):
              """运行时更新阈值"""
              self.threshold = float(threshold)

          def work(self, input_items, output_items):
              inp = input_items[0]  # 长度 = nout + ref_len - 1 (包含 history)
              out = output_items[0]
              nout = len(out)

              # 直通数据（跳过 history 部分）
              out[:] = inp[self.ref_len - 1: self.ref_len - 1 + nout]

              if nout == 0:
                  return nout

              nread = self.nitems_read(0)
              total_inp = nout + self.ref_len - 1

              # np.correlate(x, h, 'valid')[i] = sum_k x[i+k] * conj(h[k])
              # numpy 会自动对第二个参数取共轭，所以传入 self.ref 而非 self.ref_conj
              corr_abs = np.abs(np.correlate(inp[:total_inp], self.ref, mode='valid'))

              # ========== 滑窗能量归一化 ==========
              inp_sq = np.abs(inp[:total_inp]).astype(np.float64) ** 2
              cumsum = np.cumsum(inp_sq)

              win_energy = np.empty(nout, dtype=np.float64)
              win_energy[0] = cumsum[self.ref_len - 1]
              if nout > 1:
                  win_energy[1:] = (cumsum[self.ref_len: self.ref_len + nout - 1]
                                    - cumsum[: nout - 1])

              # 归一化: rho = |corr| / sqrt(E_window * E_ref)
              denom = np.sqrt(np.maximum(win_energy * self.ref_energy, 1e-30))
              norm_corr = corr_abs[:nout] / denom

              # ========== 峰值检测 ==========
              above_mask = norm_corr > self.threshold
              if not np.any(above_mask):
                  return nout

              above_indices = np.where(above_mask)[0]

              # 将连续超阈值区域分组，在每组中找峰值
              breaks = np.where(np.diff(above_indices) > 1)[0] + 1
              groups = np.split(above_indices, breaks)

              min_distance = self.ref_len

              for group in groups:
                  if len(group) == 0:
                      continue

                  # 在组内找最大归一化相关值的位置
                  peak_idx = group[np.argmax(norm_corr[group])]

                  # 只处理能映射到有效输出位置的峰值
                  # correlation at index i => ZC starts at inp[i]
                  # inp[i] 的绝对位置 = nread - (ref_len - 1) + i
                  # 要使 tag 落在当前输出范围内: i >= ref_len - 1
                  if peak_idx < self.ref_len - 1:
                      continue

                  # ZC 序列开始的绝对流位置
                  zc_start_abs = nread + (peak_idx - (self.ref_len - 1))

                  # 距上次检测的去重检查
                  if zc_start_abs - self.last_tag_abs < min_distance:
                      continue

                  # 添加 tag 标记导频起始位置
                  self.add_item_tag(
                      0,
                      zc_start_abs,
                      pmt.intern(self.tag_name),
                      pmt.from_double(float(norm_corr[peak_idx]))
                  )
                  self.last_tag_abs = zc_start_abs

              return nout
    sps: '1'
    symbols: zc1_rrced
    tag_name: '"h12_corr_start"'
    threshold: threshold
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      # h11表示 tx1 到 rx1 的信道，h21 表示 tx2 到 rx1 的信道，h12 表示 tx1 到 rx2 的信道，h22 表示 tx2 到 rx2 的信道
      #
      #
      #

      class blk(gr.basic_block):  # 使用 basic_block 实现灵活的帧处理
          """2x2 MIMO 检测块，使用 ZF (迫零) 算法"""

          def __init__(self, frame_len=1008):  # frame_len = 应用层总帧长(QPSK符号数)
              """函数参数会在 GRC 中显示为块的参数"""
              gr.basic_block.__init__(
                  self,
                  name='MIMO_Detection',   # 将在 GRC 中显示为块名称
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              
              #debug
              self.message_port_register_out(pmt.intern("message_out"))#注册输出端口

              # 参数设置
              self.sps = 1  # 升采样因子
              self.zero_len = 32 * self.sps  # 零序列长度
              self.zc_len = 61 * self.sps  # ZC 序列长度
              # frame_len 直接就是每路 QPSK 符号数（即 RF 数据区长度）
              self.data_len = frame_len * self.sps
              # 前导结构: zero(32) + zc1(61) + zero(32) + zc2(61) + zero(32) = 218
              self.preamble_len = self.zero_len + self.zc_len + self.zero_len + self.zc_len + self.zero_len
              self.frame_len = self.preamble_len + self.data_len  # 总帧长度 = 218 + 1000 = 1218

              # ZC 序列生成
              self.zc1 = np.array([complex(np.exp(-1j * np.pi * 25 * n * (n + 1) / 61)) for n in range(61)])  # ZC1 序列
              self.zc2 = np.array([complex(np.exp(-1j * np.pi * 34 * n * (n + 1) / 61)) for n in range(61)])  # ZC2 序列
              self.zc1_up = np.repeat(self.zc1, self.sps)  # ZC1 升采样
              self.zc2_up = np.repeat(self.zc2, self.sps)  # ZC2 升采样

              # ZC 在帧内的预期位置
              self.zc1_pos = self.zero_len  # = 32
              self.zc2_pos = self.zero_len + self.zc_len + self.zero_len  # = 32 + 61 + 32 = 125

              # 状态变量
              self.frame_start_idx = -1  # 帧起始的相对索引，-1 表示未找到

              # 诊断计数器
              self._diag_calls = 0
              self._diag_tag_found = 0
              self._diag_tag_missing = 0
              self._diag_frames_out = 0
              self._diag_last_print = 0
              import time as _time
              self._diag_t0 = _time.time()

          def general_work(self, input_items, output_items):
              """执行 MIMO 检测，使用 ZF 算法的帧处理模式

              关键点：以 RX1 为基准同步
              """
              rx1 = input_items[0]  # 接收端 1 的输入
              rx2 = input_items[1]  # 接收端 2 的输入
              out_rx1 = output_items[0]  # 接收端 1 的输出
              out_rx2 = output_items[1]  # 接收端 2 的输出

              nin0 = len(rx1)
              nin1 = len(rx2)
              nin = min(nin0, nin1)

              # 如果没有输入数据，直接返回
              if nin == 0:
                  return 0

              # 诊断：每5秒打印一次统计
              import time as _time
              self._diag_calls += 1
              now = _time.time()
              if now - self._diag_last_print >= 5.0:
                  elapsed = now - self._diag_t0
                  print(f"[EPY2 DIAG] t={elapsed:.0f}s calls={self._diag_calls} "
                        f"tag_found={self._diag_tag_found} tag_miss={self._diag_tag_missing} "
                        f"frames_out={self._diag_frames_out} nin={nin}")
                  self._diag_last_print = now

              # 获取当前输入块的绝对位置范围（分别对应两个端口）
              abs_start0 = self.nitems_read(0)
              abs_end0 = abs_start0 + nin0
              abs_start1 = self.nitems_read(1)
              abs_end1 = abs_start1 + nin1

              # 第一步：以 RX1 为基准，寻找帧起始标记
              if self.frame_start_idx < 0:
                  # 使用 get_tags_in_range（绝对偏移）获取 RX1 上的帧起始标记
                  h11_tags = self.get_tags_in_range(0, abs_start0, abs_end0, pmt.intern("h11_corr_start"))
                  if h11_tags:
                      self._diag_tag_found += 1
                      # 找到帧起始，保存其相对于当前输入块的索引
                      # 标签在 ZC1 起始处，所以帧起始是标签位置减去 zero_len
                      tag_rel = h11_tags[0].offset - abs_start0
                      self.frame_start_idx = tag_rel - self.zero_len
                      if self.frame_start_idx < 0:
                          # 帧起始在当前缓冲区之前（ZC 标签偏移 < zero_len）
                          # 跳过当前帧的剩余部分（跳到帧末尾），让下次能找到下一帧
                          skip = self.frame_len + self.frame_start_idx  # = frame_len - |offset|
                          if skip <= 0:
                              skip = 1
                          safe = min(skip, nin)  # 两路消耗相同量，保持Δ不变
                          self.consume(0, safe)
                          self.consume(1, safe)
                          self.frame_start_idx = -1
                          return 0
                  else:
                      self._diag_tag_missing += 1
                      # 尚未找到帧起始，消费大部分数据以避免死循环
                      skip = max(1, nin - self.frame_len)
                      self.consume(0, skip)
                      self.consume(1, skip)
                      return 0

              # 若帧起始偏移 > 0，先消耗偏移前数据，让调度器下次能提供足够数据
              if self.frame_start_idx > 0:
                  skip = self.frame_start_idx
                  safe = min(skip, nin)  # 两路消耗相同量，保持Δ不变
                  self.consume(0, safe)
                  self.consume(1, safe)
                  self.frame_start_idx -= safe  # 减去已消耗量；=0时进入帧处理
                  return 0

              # 检查是否有足够数据处理完整帧 (frame_start_idx 此时为 0)
              if self.frame_len > nin0 or self.frame_len > nin1:
                  return 0

              # 检查输出缓冲区是否足够
              if len(out_rx1) < self.data_len or len(out_rx2) < self.data_len:
                  return 0

              # 数据足够，从当前输入块中提取完整帧
              frame_rx1 = rx1[self.frame_start_idx : self.frame_start_idx + self.frame_len]
              frame_rx2 = rx2[self.frame_start_idx : self.frame_start_idx + self.frame_len]

              # 帧的绝对位置范围
              frame_abs_start0 = abs_start0 + self.frame_start_idx
              frame_abs_end0 = frame_abs_start0 + self.frame_len
              frame_abs_start1 = abs_start1 + self.frame_start_idx
              frame_abs_end1 = frame_abs_start1 + self.frame_len

              # 第二步：在完整帧范围内获取各信道的标签
              # 端口 0 (rx1): h11_corr_start, h21_corr_start
              h11_tags = self.get_tags_in_range(0, frame_abs_start0, frame_abs_end0, pmt.intern("h11_corr_start"))
              h21_tags = self.get_tags_in_range(0, frame_abs_start0, frame_abs_end0, pmt.intern("h21_corr_start"))
              # 端口 1 (rx2): h22_corr_start, h12_corr_start
              h22_tags = self.get_tags_in_range(1, frame_abs_start1, frame_abs_end1, pmt.intern("h22_corr_start"))
              h12_tags = self.get_tags_in_range(1, frame_abs_start1, frame_abs_end1, pmt.intern("h12_corr_start"))

              def get_tag_offset_p0(tags, default_pos):
                  """获取端口0标签相对帧起始的偏移，若未找到则使用默认位置"""
                  return (tags[0].offset - frame_abs_start0) if tags else default_pos

              def get_tag_offset_p1(tags, default_pos):
                  """获取端口1标签相对帧起始的偏移，若未找到则使用默认位置"""
                  return (tags[0].offset - frame_abs_start1) if tags else default_pos

              if not h11_tags and not h21_tags:
                  # 未找到 RX1 上的必要标签，跳过并继续搜索
                  self.consume(0, 1)
                  self.consume(1, 1)
                  self.frame_start_idx = -1
                  return 0

              # 第三步：信道估计
              h11_offset = get_tag_offset_p0(h11_tags, self.zc1_pos)
              h21_offset = get_tag_offset_p0(h21_tags, self.zc2_pos)
              # 使用端口0的偏移(基于Δ=0同步假设)，避免端口1标签误检导致h22/h12估计错误
              h22_offset = h21_offset
              h12_offset = h11_offset

              # 确保偏移在有效范围内
              h11_offset = max(0, min(h11_offset, self.frame_len - self.zc_len))
              h21_offset = max(0, min(h21_offset, self.frame_len - self.zc_len))
              h22_offset = max(0, min(h22_offset, self.frame_len - self.zc_len))
              h12_offset = max(0, min(h12_offset, self.frame_len - self.zc_len))

              # 提取 ZC 部分并估计信道
              y11 = frame_rx1[h11_offset : h11_offset + self.zc_len]  # rx1 接收的 tx1 信号
              h11 = np.mean(y11 / self.zc1_up) if len(y11) == self.zc_len else 0  # h11 信道估计

              y21 = frame_rx1[h21_offset : h21_offset + self.zc_len]  # rx1 接收的 tx2 信号
              h21 = np.mean(y21 / self.zc2_up) if len(y21) == self.zc_len else 0  # h21 信道估计

              y22 = frame_rx2[h22_offset : h22_offset + self.zc_len]  # rx2 接收的 tx2 信号
              h22 = np.mean(y22 / self.zc2_up) if len(y22) == self.zc_len else 0  # h22 信道估计

              y12 = frame_rx2[h12_offset : h12_offset + self.zc_len]  # rx2 接收的 tx1 信号
              h12 = np.mean(y12 / self.zc1_up) if len(y12) == self.zc_len else 0  # h12 信道估计

              # 数据起始位置（前导之后）
              data_start = self.preamble_len

              # 提取数据部分
              y1_data = frame_rx1[data_start : data_start + self.data_len]  # rx1 接收的数据
              y2_data = frame_rx2[data_start : data_start + self.data_len]  # rx2 接收的数据

              # ZF (迫零) 检测
              # 信道模型: y1 = h11*x1 + h21*x2, y2 = h12*x1 + h22*x2
              # H^-1 = (1/det) * [[h22, -h21], [-h12, h11]], det = h11*h22 - h21*h12
              det = h11 * h22 - h21 * h12  # 采用 ZF 算法计算检测矩阵行列式
              if abs(det) > 1e-10:
                  x1_est = (h22 * y1_data - h21 * y2_data) / det  # 估计的 tx1 数据
                  x2_est = (h11 * y2_data - h12 * y1_data) / det  # 估计的 tx2 数据
                  if self._diag_frames_out < 20 or self._diag_frames_out % 50 == 0:
                      delta = abs_start1 - abs_start0
                      print(f"[ZF #{self._diag_frames_out}] h11={h11:.3f} h22={h22:.3f} det={det:.3e} "
                            f"Δ={delta} h22off={h22_offset} x1_abs={float(np.mean(np.abs(x1_est))):.3f}")
              else:
                  # 矩阵奇异，直接输出接收数据
                  x1_est = y1_data
                  x2_est = y2_data
                  delta = abs_start1 - abs_start0
                  print(f"[ZF #{self._diag_frames_out}] SINGULAR h11={h11:.3f} h22={h22:.3f} det={det:.3e} "
                        f"Δ={delta} h22off={h22_offset}")

              # 输出检测结果
              n_out = min(len(x1_est), len(x2_est), len(out_rx1), len(out_rx2))
              out_rx1[:n_out] = x1_est[:n_out].astype(np.complex64)
              out_rx2[:n_out] = x2_est[:n_out].astype(np.complex64)

              # 添加数据包长度标签
              self.add_item_tag(0, self.nitems_written(0), pmt.intern("rx1_packet_len"), pmt.from_long(n_out))
              self.add_item_tag(1, self.nitems_written(1), pmt.intern("rx2_packet_len"), pmt.from_long(n_out))

              # 消费已处理的帧数据，重置状态以寻找下一帧
              consumed = self.frame_start_idx + self.frame_len
              self.consume(0, consumed)
              self.consume(1, consumed)
              self.frame_start_idx = -1  # 重置帧起始标记
              self._diag_frames_out += 1

              return n_out
    comment: |-
      每应用帧 = 4B头 + 1000B负载 = 1004 字节
                      ↓ deinterleave解交织
                  502 字节/路
                      ↓ repack 8→2
                  2008 dibits/路
                      ↓ chunks_to_symbols
                  2008 QPSK符号/路   ← TX 实际发出
    frame_len: '1000'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: RX 信宿 (数据链路层)

      DLL 帧格式:
        access_code(8B) + packet_len(2B,仅payload长度) + SN(2B) + payload

      SN=0  → test 模式: 把 payload 数据打印到终端
      SN>0  → transfer 模式: 收集各帧 payload，全部到齐后写入文件

      ACCESS_CODE = [0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]
      """

      import numpy as np
      from gnuradio import gr
      import struct
      import os
      import random as _random
      import collections as _coll
      import pmt

      ACCESS_CODE      = bytes([0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc])
      AC_LEN           = len(ACCESS_CODE)   # 8
      HEADER_LEN       = AC_LEN + 2 + 2     # access_code + packet_len + SN = 12
      MAX_PAYLOAD      = 488                # 最大有效载荷长度（字节）
      SAVE_AFTER_CYCLES = 5                 # 累积 5 轮完整文件后投票保存

      _rng = _random.Random(0xDEADBEEF)
      _SCRAMBLE_KEY = bytes([_rng.randint(0, 255) for _ in range(MAX_PAYLOAD)])
      del _rng


      def _descramble(payload):
          key = _SCRAMBLE_KEY[:len(payload)]
          return bytes([b ^ k for b, k in zip(payload, key)])


      class blk(gr.sync_block):
          """RX 信宿：在字节流中搜索 access code，解析 DLL 帧"""

          def __init__(self, file_path="./receive_a.jpg"):
              gr.sync_block.__init__(
                  self,
                  name='RX Sink',
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.file_path = file_path

              self.message_port_register_in(pmt.intern('auto'))
              self.set_msg_handler(pmt.intern('auto'), self._handle_auto_msg)

              self._buf = bytearray()
              self._total_in = 0
              self._logged_raw = False
              self._after_auto = False
              self._after_auto_bytes = 0
              self._after_auto_ac = 0
              self._after_auto_next_report = 50000

              # test 统计
              self._test_cnt = 0

              # transfer 收集
              self._frames = {}         # sn -> 最新 payload
              self._frames_votes = {}   # sn -> 多轮 payload 列表
              self._max_sn = 0          # 目前收到过的最大 SN
              self._transfer_active = False
              self._zero_after_transfer = 0
              self._got_last_frame = False
              self._cycle_count = 0
              self._transfer_done = False

          def _handle_auto_msg(self, msg):
              self._after_auto = True
              self._after_auto_bytes = 0
              self._after_auto_ac = 0
              self._after_auto_next_report = 50000
              print("[RX] 开始统计 AUTO 后字节和 AC 命中")

          # ---------------------------------------------------------------- work
          def work(self, input_items, output_items):
              data = input_items[0]
              self._buf.extend(data.tobytes())
              self._total_in += len(data)

              if not self._logged_raw and self._total_in >= 20:
                  raw = bytes(self._buf[:min(24, len(self._buf))])
                  print(f"[RX] 首批字节: {raw.hex(' ')}")
                  self._logged_raw = True

              if self._after_auto:
                  self._after_auto_bytes += len(data)
                  chunk = bytes(data)
                  pos = 0
                  while True:
                      idx = chunk.find(ACCESS_CODE, pos)
                      if idx < 0:
                          break
                      self._after_auto_ac += 1
                      pos = idx + 1
                  while self._after_auto_bytes >= self._after_auto_next_report:
                      print(f"[RX DIAG] AUTO后收到 {self._after_auto_bytes} 字节, "
                            f"AC命中 {self._after_auto_ac} 次, "
                            f"buf_len={len(self._buf)}")
                      self._after_auto_next_report += 50000

              self._parse()
              return len(data)

          # ---------------------------------------------------------------- parse
          def _parse(self):
              """在缓冲中搜索 access code，逐帧解析"""
              while True:
                  # 在缓冲中搜索 access code
                  idx = self._buf.find(ACCESS_CODE)
                  if idx < 0:
                      # 没找到；保留最后 AC_LEN-1 字节防止跨块
                      keep = AC_LEN - 1
                      if len(self._buf) > keep:
                          del self._buf[:len(self._buf) - keep]
                      return

                  # 找到 access code 但 header 数据不够
                  if len(self._buf) < idx + HEADER_LEN:
                      # 丢弃 access code 之前的数据，等待更多
                      if idx > 0:
                          del self._buf[:idx]
                      return

                  # 读取 header
                  pkt_len = struct.unpack_from('>H', self._buf, idx + AC_LEN)[0]
                  sn      = struct.unpack_from('>H', self._buf, idx + AC_LEN + 2)[0]

                  # 合法性检查
                  if pkt_len == 0 or pkt_len > MAX_PAYLOAD:
                      # 非法，跳过这一个 access code 字节继续搜索
                      del self._buf[:idx + 1]
                      continue

                  # 检查 payload 是否到齐
                  frame_end = idx + HEADER_LEN + pkt_len
                  if len(self._buf) < frame_end:
                      # payload 还没到
                      if idx > 0:
                          del self._buf[:idx]
                      return

                  # 提取 payload 并解扰
                  payload = _descramble(bytes(self._buf[idx + HEADER_LEN: frame_end]))
                  del self._buf[:frame_end]

                  # 分发处理
                  if sn == 0:
                      self._handle_test(payload)
                  else:
                      self._handle_transfer(sn, payload)

          # ---------------------------------------------------------------- test
          def _handle_test(self, payload):
              """SN=0 test 帧"""
              # 如果刚完成 transfer，检查是否连续收到几个 test 帧就可以保存文件
              if self._transfer_active:
                  self._zero_after_transfer += 1
                  if self._zero_after_transfer >= 2:
                      if not self._transfer_done:
                          self._save_file()
                          self._transfer_done = True
                      self._transfer_active = False
                      self._zero_after_transfer = 0
              else:
                  self._zero_after_transfer = 0

              self._test_cnt += 1
              if self._test_cnt <= 20 or self._test_cnt % 100 == 0:
                  vals = list(payload[:40])
                  print(f"[TEST #{self._test_cnt}] len={len(payload)} "
                        f"vals={vals}{'...' if len(payload) > 40 else ''}")

          # ---------------------------------------------------------------- transfer
          def _handle_transfer(self, sn, payload):
              """SN>0 transfer 帧，存入字典等待拼装"""
              if self._transfer_done:
                  return

              if not self._transfer_active:
                  print(f"[TRANSFER] 开始接收，首帧 SN={sn}")
                  self._transfer_active = True
                  self._zero_after_transfer = 0

              self._frames[sn] = payload
              self._frames_votes.setdefault(sn, []).append(payload)
              if sn > self._max_sn:
                  self._max_sn = sn
              if len(payload) < MAX_PAYLOAD:
                  self._got_last_frame = True

              n_recv = len(self._frames)
              if n_recv <= 5 or n_recv % 10 == 0:
                  print(f"[TRANSFER] 已收 {n_recv} 帧 (max_sn={self._max_sn})")

              if self._got_last_frame and self._max_sn > 0 and len(self._frames) == self._max_sn:
                  self._cycle_count += 1
                  print(f"[TRANSFER] 第{self._cycle_count}次全部{self._max_sn}帧到齐")
                  if self._cycle_count >= SAVE_AFTER_CYCLES:
                      print(f"[TRANSFER] 已积累{self._cycle_count}轮，开始投票保存")
                      self._save_file()
                      self._transfer_active = False
                      self._transfer_done = True
                  self._got_last_frame = False

          def _vote_payload(self, votes):
              length_mode = _coll.Counter(len(v) for v in votes).most_common(1)[0][0]
              valid_votes = [v for v in votes if len(v) == length_mode]
              return bytes([
                  _coll.Counter(v[i] for v in valid_votes).most_common(1)[0][0]
                  for i in range(length_mode)
              ])

          # ---------------------------------------------------------------- save
          def _save_file(self):
              """按 SN 顺序拼装并写入文件，使用逐字节多数投票"""
              if not self._frames_votes:
                  print("[TRANSFER] 无数据帧，跳过保存")
                  return

              max_sn = self._max_sn
              present = sorted(self._frames_votes.keys())
              total_bytes = 0

              d = os.path.dirname(self.file_path)
              if d:
                  os.makedirs(d, exist_ok=True)
              with open(self.file_path, 'wb') as f:
                  for sn in range(1, max_sn + 1):
                      votes = self._frames_votes.get(sn)
                      if not votes:
                          print(f"[TRANSFER] 警告: SN={sn} 丢失")
                          continue
                      payload = self._vote_payload(votes)
                      f.write(payload)
                      total_bytes += len(payload)

              avg_votes = sum(len(votes) for votes in self._frames_votes.values()) / max(len(self._frames_votes), 1)
              print(f"[TRANSFER] 文件保存完成: {self.file_path} "
                    f"({total_bytes} 字节, 收到 {len(present)}/{max_sn} 帧, 平均{avg_votes:.1f}票/帧)")

              # 重置
              self._frames.clear()
              self._frames_votes.clear()
              self._max_sn = 0
              self._got_last_frame = False
              self._cycle_count = 0

          # ---------------------------------------------------------------- stop
          def stop(self):
              """flowgraph 停止时，如有未完成的 transfer 也保存"""
              if self._transfer_active and self._frames_votes and not self._transfer_done:
                  print("[RX] flowgraph 停止，保存当前投票结果")
                  self._save_file()
              return True
    file_path: '"./receive_a33.jpg"'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: TX 信源 (数据链路层)

      DLL 帧格式:
        access_code(8B) + packet_len(2B,仅payload长度) + SN(2B) + payload

      SN=0  → test 模式: payload = 0..50 循环整数
      SN>0  → transfer 模式: payload = 目标文件分片 (SN从1开始递增)

      ACCESS_CODE = [0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import threading
      import random as _random

      ACCESS_CODE = bytes([0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc])
      MAX_PAYLOAD = 488   # 每DLL帧最大payload字节数
      N_LOOPS     = 50    # 文件循环重发次数

      _rng = _random.Random(0xDEADBEEF)
      _SCRAMBLE_KEY = bytes([_rng.randint(0, 255) for _ in range(MAX_PAYLOAD)])
      del _rng


      def _scramble(payload):
          key = _SCRAMBLE_KEY[:len(payload)]
          return bytes([b ^ k for b, k in zip(payload, key)])


      class blk(gr.sync_block):
          """TX 信源：通过消息切换 test/transfer 模式，输出DLL帧字节流"""

          def __init__(self, file_path="/home/adminx/mytest/a.jpg", payload_data_len=488):
              gr.sync_block.__init__(
                  self,
                  name='TX Source',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.message_port_register_in(pmt.intern('test/transfer'))
              self.set_msg_handler(pmt.intern('test/transfer'), self._handle_msg)

              self.file_path = file_path
              self.payload_data_len = MAX_PAYLOAD  # 忽略外部传入，用内部常量

              self._mode = 0          # 0=test, 1=transfer
              self._buf = bytearray()
              self._lock = threading.Lock()

              self._test_ctr = 0      # test 数据计数器 (0-50 循环)
              self._file_data = b''
              self._file_offset = 0
              self._sn = 0            # 当前 transfer SN (从1开始)
              self._transfer_done = False
              self._loop_count = 0
              self._n_frames = 0

          # ---------------------------------------------------------------- message
          def _handle_msg(self, msg):
              """接收切换消息"""
              try:
                  if pmt.is_pair(msg):
                      mode = int(pmt.to_long(pmt.cdr(msg)))
                  elif pmt.is_integer(msg):
                      mode = int(pmt.to_long(msg))
                  else:
                      return
              except Exception:
                  return

              with self._lock:
                  if mode == 1 and self._mode == 0:
                      try:
                          with open(self.file_path, 'rb') as f:
                              self._file_data = f.read()
                          self._file_offset = 0
                          self._sn = 1
                          self._transfer_done = False
                          self._loop_count = 0
                          self._n_frames = (len(self._file_data) + MAX_PAYLOAD - 1) // MAX_PAYLOAD
                          print(f"[TX] 开始传输: {self.file_path} "
                                f"({len(self._file_data)} 字节, {self._n_frames} DLL帧, 循环 {N_LOOPS} 次)")
                      except Exception as e:
                          print(f"[TX] 文件读取失败: {e}")
                          return
                      self._mode = 1
                  elif mode == 0:
                      print("[TX] 切换到 test 模式")
                      self._mode = 0

          # ---------------------------------------------------------------- frame builders
          def _make_test_frame(self):
              """SN=0, payload=0..50循环，加扰后发送"""
              payload = bytes([self._test_ctr % 51 for _ in range(MAX_PAYLOAD)])
              self._test_ctr = (self._test_ctr + MAX_PAYLOAD) % 51
              return ACCESS_CODE + struct.pack('>HH', MAX_PAYLOAD, 0) + _scramble(payload)

          def _make_transfer_frame(self):
              """SN=递增, payload=文件分片; 每轮结束后按 N_LOOPS 重发"""
              remaining = len(self._file_data) - self._file_offset
              if remaining <= 0:
                  self._loop_count += 1
                  if self._loop_count >= N_LOOPS:
                      self._transfer_done = True
                      self._mode = 0
                      print(f"[TX] 传输完成，共循环 {self._loop_count} 次 "
                            f"({self._n_frames} 帧/轮)，返回 test 模式")
                      return self._make_test_frame()

                  self._file_offset = 0
                  self._sn = 1
                  if self._loop_count <= 3 or self._loop_count % 10 == 0:
                      print(f"[TX] 第 {self._loop_count}/{N_LOOPS} 轮完成，重新发送")
                  remaining = len(self._file_data)

              chunk = self._file_data[self._file_offset:self._file_offset + MAX_PAYLOAD]
              pkt_len = len(chunk)
              frame = ACCESS_CODE + struct.pack('>HH', pkt_len, self._sn) + _scramble(chunk)
              self._file_offset += pkt_len
              if self._loop_count == 0 and (self._sn <= 3 or self._sn % 10 == 0):
                  print(f"[TX] transfer SN={self._sn} pkt_len={pkt_len} "
                        f"offset={self._file_offset}/{len(self._file_data)}")
              self._sn += 1
              return frame

          # ---------------------------------------------------------------- work
          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              produced = 0

              with self._lock:
                  # 先消耗缓冲中的残余
                  if self._buf:
                      to_copy = min(n, len(self._buf))
                      out[:to_copy] = np.frombuffer(bytes(self._buf[:to_copy]),
                                                    dtype=np.uint8)
                      del self._buf[:to_copy]
                      produced = to_copy

                  # 生成新帧填充剩余输出
                  while produced < n:
                      if self._mode == 1 and not self._transfer_done:
                          frame = self._make_transfer_frame()
                      else:
                          frame = self._make_test_frame()

                      can_copy = min(n - produced, len(frame))
                      out[produced:produced + can_copy] = np.frombuffer(
                          frame[:can_copy], dtype=np.uint8)
                      if can_copy < len(frame):
                          self._buf.extend(frame[can_copy:])
                      produced += can_copy

              return produced
    file_path: file_path
    payload_data_len: data_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      **天线 1 (TX1) 帧格式**： `[0]*32 + [ZC 序列 1] + [等长零序列] + [0]*32 + [数据流 1]`

      **天线 2 (TX2) 帧格式**： `[0]*32 + [等长零序列] + [ZC 序列 2] + [0]*32 + [数据流 2]`
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"linear 1"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"linear 2"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_3
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"mimo 1"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_4
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"mimo 2"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tx1"'
    size: '8196'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tx1"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"rx1"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"rx2"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"tx2"'
    size: '8196'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"tx2"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"out1"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"in1"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_1_4
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"out2"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_1_4_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"in2"'
    size: '8192'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '4'
    interp: '4'
    ntaps: 11*sample_rate
    samp_rate: sample_rate
    sym_rate: '1.0'
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '4'
    interp: '4'
    ntaps: 11*sample_rate
    samp_rate: sample_rate
    sym_rate: '1.0'
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: int(center_freq)
    center_freq1: int(center_freq)
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: int(center_freq)
    center_freq1: int(center_freq)
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: mimo_out1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: mimo_out2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: mimo_out2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: mimo_out1
  states: {}
- name: vr
  id: epy_module
  parameters:
    comment: |-
      rrc_interpolation_filter(input_signal, interpolation, gain, samplerate, symbol_rate, alpha, num_taps)
      -----------
          input_signal : list of complex
              输入复数信号
          interpolation : int
              插值倍数（输出采样率 = 输入采样率 * interpolation）
          gain : float
              滤波器增益系数
          samplerate : float
              输出采样率 (Hz)
          symbol_rate : float
              符号率 (Hz)
          alpha : float
              RRC滚降系数 (0 < alpha <= 1)
          num_taps : int
              滤波器抽头数（必须是奇数）
          
          返回：
          --------
          output_signal : list of complex
              滤波后的复数信号
          """
    source_code: |-
      import numpy as np
      from scipy import signal
      from gnuradio.filter import firdes


      def rrc_interpolation_filter(input_signal, interpolation, gain, *args):
          """
          RRC（Root Raised Cosine）插值滤波器

          使用 GNU Radio firdes.root_raised_cosine 生成滤波器抽头，
          确保与 TX 链路中 interp_fir_filter_ccf 使用完全相同的 RRC 脉冲形状，
          保证接收端相关性估计的参考序列与发射信号精确匹配。

          参数：
          -----------
          input_signal : list of complex
              输入复数信号
          interpolation : int
              插值倍数，同时作为每符号采样数
          gain : float
              滤波器增益系数（传给 firdes.root_raised_cosine）
          alpha : float
              RRC滚降系数 (0 < alpha <= 1)
          num_taps : int
              滤波器抽头数

          兼容旧调用格式：
          -----------
          rrc_interpolation_filter(input_signal, interpolation, gain,
                                   samplerate, symbol_rate, alpha, num_taps)
          其中 samplerate 和 symbol_rate 会被忽略。

          返回：
          --------
          output_signal : list of complex
              滤波后的复数信号
          """

          if len(args) == 2:
              alpha, num_taps = args
          elif len(args) == 4:
              _, _, alpha, num_taps = args
          else:
              raise TypeError(
                  "rrc_interpolation_filter expects (input_signal, interpolation, gain, alpha, num_taps) "
                  "or legacy (input_signal, interpolation, gain, samplerate, symbol_rate, alpha, num_taps)"
              )

          signal_array = np.asarray(input_signal, dtype=complex)

          interpolation = int(np.round(interpolation))
          if interpolation < 1:
              raise ValueError("interpolation must be a positive integer")

          alpha = float(alpha)
          if not 0 < alpha <= 1:
              raise ValueError("alpha must satisfy 0 < alpha <= 1")

          num_taps = int(np.round(num_taps))
          if num_taps < 1:
              raise ValueError("num_taps must be positive")

          if signal_array.size == 0:
              return []

          # 始终使用 interpolation 作为 firdes gain，与 TX 链路中
          # interp_fir_filter_ccf 使用的 firdes.root_raised_cosine(interpolation, ...)
          # 完全一致，确保参考序列幅度匹配发射信号。
          # （忽略调用者传入的 gain 参数，因为 corr_est_cc 的 THRESHOLD_ABSOLUTE
          #  阈值 = threshold * symbols_energy²，参考序列幅度必须与 TX 信号匹配。）
          firdes_gain = float(interpolation)
          h = np.array(firdes.root_raised_cosine(
              firdes_gain, interpolation, 1.0, alpha, num_taps))

          interpolated_signal = np.zeros(signal_array.size * interpolation, dtype=complex)
          interpolated_signal[::interpolation] = signal_array

          output_signal = signal.convolve(interpolated_signal, h, mode='same')

          return output_signal.tolist()
  states: {}

connections:
- [analog_agc_xx_0, '0', epy_block_1, '0']
- [analog_agc_xx_0_0, '0', epy_block_1_1, '0']
- [blocks_deinterleave_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_deinterleave_0, '1', blocks_repack_bits_bb_0_1, '0']
- [blocks_interleave_0, '0', epy_block_3, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_interleave_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_interleave_0, '1']
- [blocks_repack_bits_bb_0_1, '0', digital_map_bb_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [blocks_tagged_stream_mux_0, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', qtgui_time_sink_x_0_0_1_1_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_throttle2_0_0_1_0, '0', epy_block_2, '0']
- [blocks_throttle2_0_0_1_0, '0', qtgui_time_sink_x_0_0_1_1_1_0, '0']
- [blocks_throttle2_0_0_1_0_0, '0', epy_block_2, '1']
- [blocks_throttle2_0_0_1_0_0, '0', qtgui_time_sink_x_0_0_1_1_1_4_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [button_msg, state, epy_block_4, test/transfer]
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_map_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_map_bb_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_throttle2_0_0_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_throttle2_0_0_1_0_0, '0']
- [epy_block_1, '0', epy_block_1_0, '0']
- [epy_block_1_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [epy_block_1_1, '0', epy_block_1_1_0, '0']
- [epy_block_1_1_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0_0_1_1_1, '0']
- [epy_block_2, '0', virtual_sink_0_1, '0']
- [epy_block_2, '1', qtgui_time_sink_x_0_0_1_1_1_4, '0']
- [epy_block_2, '1', virtual_sink_1_1, '0']
- [epy_block_4, '0', blocks_deinterleave_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_1, '0']
- [root_raised_cosine_filter_0_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '1', virtual_sink_1_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [virtual_source_0_0, '0', uhd_usrp_sink_0, '1']
- [virtual_source_0_0_0, '0', analog_agc_xx_0_0, '0']
- [virtual_source_0_0_1, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_const_sink_x_0_4, '0']
- [virtual_source_0_1, '0', analog_agc_xx_0, '0']
- [virtual_source_0_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0_2, '0', qtgui_const_sink_x_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
